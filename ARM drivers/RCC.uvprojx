# Keil uVision project RCC.uvprojx, settings and files
target APP (6160000::V6.16::ARMCLANG)
  device: STM32F401CCUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RCC
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\inc\MCAL\RCC;.\inc\LIB;.\src;.\inc\LIB;.\inc\MCAL\GPIO;.\inc\MCAL\SYSTIC
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application
    ./src/: main.c RCC.c GPIO.c SYSTIC.c
    ./inc/MCAL/RCC/: RCC_prv.h RCC.h RCC_cfg.h
    ./inc/LIB/: Std_types.h Bit_utils.h
    ./inc/MCAL/GPIO/: GPIO.h GPIO_cfg.h GPIO_prv.h
    ./inc/MCAL/SYSTIC/: SYSTIC.h SYSTIC_cfg.h SYSTIC_prv.h
software components: CMSIS:CORE 5.6.0, Device:Startup 2.6.3
