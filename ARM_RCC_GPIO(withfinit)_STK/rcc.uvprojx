# Keil uVision project rcc.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F401CCUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rcc +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: main.c RCC.h RCC.c BIT_UTILS.h STD_TYPES.h RCC_cfg.h RCC_prv.h GPIO.c GPIO.h GPIO_prv.h GPIO_cfg.h SYSTICK.c SYSTICK.h SYSTICK_prv.h SYSTICK_cfg.h
software components: CMSIS:CORE 5.6.0, Device:Startup 2.6.3
