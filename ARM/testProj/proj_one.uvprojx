# Keil uVision project proj_one.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F401CCUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: proj_one +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\testProj
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: main.c helpers.h std_types.h RCC.c rcc.h RCC_pv.h GPIO.h GPIO.c GPIO_prv.h bit_math.h GPIO_cfg.h SysTick.h SysTick_prv.h SysTick.c SysTick_cfg.h
software components: CMSIS:CORE 5.3.0, Device:Startup 2.6.3
